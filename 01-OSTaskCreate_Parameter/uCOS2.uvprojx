# Keil uVision project uCOS2.uvprojx, settings and files
target STM32F429_uCOS2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uCOS2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: .\User;..\00-BSP;..\00-Utilities;..\00-Libraries\STM32F4xx_StdPeriph_Driver\inc;..\00-Libraries\CMSIS\Include;..\00-Libraries\CMSIS\Device\Include;..\00-Micrium\uC-Cfg;..\00-Micrium\uC-CPU;..\00-Micrium\uC-CPU\ARM-Cortex-M4;..\00-Micrium\uC-LIB;..\00-Micrium\uCOS-II\Ports;..\00-Micrium\uCOS-II\Source
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group CMSIS
    ../00-Libraries/CMSIS/Device/Source/: system_stm32f4xx.c startup_stm32f429_439xx.s
  group BSP
    ../00-BSP/: bsp.c
  group StdPeriph_Driver
    ../00-Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group Utilities
    ../00-Utilities/: stm32f4_gpio.c stm32f4_usart.c
  group uC/Cfg
    ../00-Micrium/uC-Cfg/: app_hooks.c app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h
  group uC/CPU
    ../00-Micrium/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../00-Micrium/uC-CPU/ARM-Cortex-M4/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../00-Micrium/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../00-Micrium/uC-LIB/Ports/: lib_mem_a.asm
  group uC/OS-II Ports
    ../00-Micrium/uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-II Source
    ../00-Micrium/uCOS-II/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
